## config/boards/shields/Kconfig.shield
```kconfig
if SHIELD_BP01

config SHIELD_BP01
    def_bool $(shields_list_contains,bp01)

endif
```
